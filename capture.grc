options:
  parameters:
    author: Nick Schwarzenberg
    generate_options: qt_gui
    id: capture
    output_language: python
    realtime_scheduling: '1'
    title: Raw Capturing
  states: {}

blocks:
- name: batch_size_samples
  id: variable
  parameters:
    value: 8*256
  states: {}
- name: capture_interval_ms
  id: variable
  parameters:
    value: '10'
  states: {}
- name: center_freq_mhz
  id: variable
  parameters:
    value: '3750'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"capture_"+datetime.now().strftime("%Y-%m-%d_%H-%M-%S")+"_"+str(center_freq_mhz)+"MHz_"+str(int(samp_rate/1e6))+"MSps_"+str(batch_size_samples)+"S_"+str(capture_interval_ms)+"ms.dat"'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: batch_size_samples
    n: int( capture_interval_ms/1e3 * samp_rate )
    offset: '0'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_mhz*1e6
    fftsize: batch_size_samples
    legend: 'False'
    name: '"Raw Input Frequency Spectrum"'
    type: complex
    update_time: '0.1'
    wintype: window.WIN_RECTANGULAR
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    legend: 'False'
    name: '"Raw Input Power over Time"'
    size: batch_size_samples*4
    srate: samp_rate
    type: float
    ylabel: '"Relative Gain (dB)"'
    ymax: '0'
    ymin: '-60'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq_mhz*1e6
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_m_in_n_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_keep_m_in_n_0, '0']

metadata:
  file_format: 1
