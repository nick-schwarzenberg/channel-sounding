options:
  parameters:
    author: Nick Schwarzenberg
    generate_options: qt_gui
    id: analyze
    output_language: python
    realtime_scheduling: '1'
    title: Sounding Analyzer
  states: {}

blocks:
- name: center_freq_mhz
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Center Frequency (MHz)
    min_len: '10'
    start: '70'
    step: '0.1'
    stop: '6000'
    value: '3750'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: RX Gain (dB)
    start: '0'
    step: '1'
    stop: '65'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (1+0j,1.0000+0.0000j,0.9997-0.0246j,0.9973-0.0739j,0.9891-0.1473j,0.9698-0.2439j,0.9325-0.3612j,0.8691-0.4947j,0.7713-0.6365j,0.6317-0.7752j,0.4457-0.8952j,0.2139-0.9768j,-0.0554-0.9985j,-0.3439-0.9390j,-0.6221-0.7829j,-0.8502-0.5264j,-0.9830-0.1837j,-0.9781+0.2079j,-0.8090+0.5878j,-0.4785+0.8781j,-0.0308+0.9995j,0.4457+0.8952j,0.8302+0.5575j,0.9988+0.0493j,0.8691-0.4947j,0.4457-0.8952j,-0.1534-0.9882j,-0.7136-0.7005j,-0.9939-0.1107j,-0.8370+0.5472j,-0.2737+0.9618j,0.4457+0.8952j,0.9411+0.3382j,0.9032-0.4291j,0.3090-0.9511j,-0.5000-0.8660j,-0.9830-0.1837j,-0.7634+0.6459j,0.0431+0.9991j,0.8302+0.5575j,0.9325-0.3612j,0.2139-0.9768j,-0.7136-0.7005j,-0.9667+0.2558j,-0.2499+0.9683j,0.7390+0.6737j,0.9325-0.3612j,0.0677-0.9977j,-0.8868-0.4622j,-0.7634+0.6459j,0.3324+0.9432j,1.0000+0.0000j,0.3090-0.9511j,-0.8233-0.5677j,-0.7634+0.6459j,0.4457+0.8952j,0.9698-0.2439j,-0.0554-0.9985j,-0.9939-0.1107j,-0.2499+0.9683j,0.9325+0.3612j,0.4457-0.8952j,-0.8629-0.5053j,-0.5421+0.8403j,0.8302+0.5575j,0.5524-0.8336j,-0.8502-0.5264j,-0.4785+0.8781j,0.9135+0.4067j,0.3090-0.9511j,-0.9830-0.1837j,-0.0308+0.9995j,0.9891-0.1473j,-0.3439-0.9390j,-0.8370+0.5472j,0.7390+0.6737j,0.4457-0.8952j,-0.9872-0.1595j,0.1656+0.9862j,0.8691-0.4947j,-0.7791-0.6269j,-0.2737+0.9618j,0.9891-0.1473j,-0.5626-0.8267j,-0.4785+0.8781j,1.0000+0.0000j,-0.5000-0.8660j,-0.4785+0.8781j,0.9973-0.0739j,-0.6221-0.7829j,-0.2737+0.9618j,0.9325-0.3612j,-0.8629-0.5053j,0.1656+0.9862j,0.6317-0.7752j,-0.9981+0.0616j,0.7390+0.6737j,-0.0554-0.9985j,-0.6412+0.7674j,0.9891-0.1473j,-0.8502-0.5264j,0.3324+0.9432j,0.3090-0.9511j,-0.8090+0.5878j,0.9997-0.0246j,-0.8502-0.5264j,0.4457+0.8952j,0.0677-0.9977j,-0.5421+0.8403j,0.8691-0.4947j,-0.9981+0.0616j,0.9325+0.3612j,-0.7136-0.7005j,0.4011+0.9160j,-0.0554-0.9985j,-0.2737+0.9618j,0.5524-0.8336j,-0.7634+0.6459j,0.9032-0.4291j,-0.9781+0.2079j,1.0000+0.0000j,-0.9830-0.1837j,0.9411+0.3382j,-0.8868-0.4622j,0.8302+0.5575j,-0.7791-0.6269j,0.7390+0.6737j,-0.7136-0.7005j,0.7049+0.7093j,-0.7136-0.7005j,0.7390+0.6737j,-0.7791-0.6269j,0.8302+0.5575j,-0.8868-0.4622j,0.9411+0.3382j,-0.9830-0.1837j,1.0000+0.0000j,-0.9781+0.2079j,0.9032-0.4291j,-0.7634+0.6459j,0.5524-0.8336j,-0.2737+0.9618j,-0.0554-0.9985j,0.4011+0.9160j,-0.7136-0.7005j,0.9325+0.3612j,-0.9981+0.0616j,0.8691-0.4947j,-0.5421+0.8403j,0.0677-0.9977j,0.4457+0.8952j,-0.8502-0.5264j,0.9997-0.0246j,-0.8090+0.5878j,0.3090-0.9511j,0.3324+0.9432j,-0.8502-0.5264j,0.9891-0.1473j,-0.6412+0.7674j,-0.0554-0.9985j,0.7390+0.6737j,-0.9981+0.0616j,0.6317-0.7752j,0.1656+0.9862j,-0.8629-0.5053j,0.9325-0.3612j,-0.2737+0.9618j,-0.6221-0.7829j,0.9973-0.0739j,-0.4785+0.8781j,-0.5000-0.8660j,1.0000+0.0000j,-0.4785+0.8781j,-0.5626-0.8267j,0.9891-0.1473j,-0.2737+0.9618j,-0.7791-0.6269j,0.8691-0.4947j,0.1656+0.9862j,-0.9872-0.1595j,0.4457-0.8952j,0.7390+0.6737j,-0.8370+0.5472j,-0.3439-0.9390j,0.9891-0.1473j,-0.0308+0.9995j,-0.9830-0.1837j,0.3090-0.9511j,0.9135+0.4067j,-0.4785+0.8781j,-0.8502-0.5264j,0.5524-0.8336j,0.8302+0.5575j,-0.5421+0.8403j,-0.8629-0.5053j,0.4457-0.8952j,0.9325+0.3612j,-0.2499+0.9683j,-0.9939-0.1107j,-0.0554-0.9985j,0.9698-0.2439j,0.4457+0.8952j,-0.7634+0.6459j,-0.8233-0.5677j,0.3090-0.9511j,1.0000+0.0000j,0.3324+0.9432j,-0.7634+0.6459j,-0.8868-0.4622j,0.0677-0.9977j,0.9325-0.3612j,0.7390+0.6737j,-0.2499+0.9683j,-0.9667+0.2558j,-0.7136-0.7005j,0.2139-0.9768j,0.9325-0.3612j,0.8302+0.5575j,0.0431+0.9991j,-0.7634+0.6459j,-0.9830-0.1837j,-0.5000-0.8660j,0.3090-0.9511j,0.9032-0.4291j,0.9411+0.3382j,0.4457+0.8952j,-0.2737+0.9618j,-0.8370+0.5472j,-0.9939-0.1107j,-0.7136-0.7005j,-0.1534-0.9882j,0.4457-0.8952j,0.8691-0.4947j,0.9988+0.0493j,0.8302+0.5575j,0.4457+0.8952j,-0.0308+0.9995j,-0.4785+0.8781j,-0.8090+0.5878j,-0.9781+0.2079j,-0.9830-0.1837j,-0.8502-0.5264j,-0.6221-0.7829j,-0.3439-0.9390j,-0.0554-0.9985j,0.2139-0.9768j,0.4457-0.8952j,0.6317-0.7752j,0.7713-0.6365j,0.8691-0.4947j,0.9325-0.3612j,0.9698-0.2439j,0.9891-0.1473j,0.9973-0.0739j,0.9997-0.0246j,1.0000+0.0000j)
    vlen: fft_size
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(fft_size)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(fft_size)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '256'
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(fft_size)
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_mhz*1e6
    fftsize: fft_size
    legend: 'False'
    name: '"Frequency Response"'
    type: complex
    update_time: '0.1'
    width1: '2'
    wintype: window.WIN_RECTANGULAR
    ymax: '30'
    ymin: '-40'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    legend: 'False'
    name: '"Impulse Response"'
    size: '256'
    srate: samp_rate
    type: float
    update_time: '0.1'
    ylabel: '"Magnitude"'
    ymin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq_mhz*1e6
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_source_x_0, '0', fft_vxx_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
